File: IOB-Adapter-Minimal.brd (EAGLE design)
At the start: 15.2 x 8.9 mm, 1 part

Commit message: normalized values
Parts:
- JP1: value CONNECTOR-M05X2NO_SILK -> 0.100
